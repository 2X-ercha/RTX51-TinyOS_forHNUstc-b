# Keil uVision project RTX51Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: RTX51Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\src
  link misc: REMOVEUNUSED
  group src
    ./: STARTUP.A51
    ./src/: Conf_tny.A51 taskinit.c sys_support.c
  group include
    ./include/: sys_support.h define.h STC15F2K60S2.H
